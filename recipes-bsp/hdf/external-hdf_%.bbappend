FILESEXTRAPATHS:prepend := "${THISDIR}/../../files/zybo-z7-10:"
